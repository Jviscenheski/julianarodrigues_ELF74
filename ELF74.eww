<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lab1\helloWorld.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab2\lab2.ewp</path>
    </project>
    <batchBuild />
</workspace>
